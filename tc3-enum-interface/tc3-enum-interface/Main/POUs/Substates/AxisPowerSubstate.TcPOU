FUNCTION_BLOCK AxisPowerSubstate EXTENDS Substate
VAR
END_VAR

PROPERTY PUBLIC Name : T_MAXSTRING
GET
Name := 'AXIS_POWER';
END_GET
END_PROPERTY

END_FUNCTION_BLOCK
