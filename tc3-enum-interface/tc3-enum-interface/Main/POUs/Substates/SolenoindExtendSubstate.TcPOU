FUNCTION_BLOCK SolenoindExtendSubstate EXTENDS Substate
VAR
END_VAR

PROPERTY PUBLIC Name : T_MAXSTRING
GET
Name := 'SOLENOID_EXTEND';
END_GET
END_PROPERTY

END_FUNCTION_BLOCK
