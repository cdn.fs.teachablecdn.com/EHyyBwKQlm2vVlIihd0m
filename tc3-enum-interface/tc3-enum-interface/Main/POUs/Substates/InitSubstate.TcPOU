FUNCTION_BLOCK InitSubstate EXTENDS Substate
VAR
END_VAR

PROPERTY PUBLIC Name : T_MAXSTRING
GET
Name := 'INIT';
END_GET
END_PROPERTY

END_FUNCTION_BLOCK
